VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO d_ff
  CLASS BLOCK ;
  FOREIGN d_ff ;
  ORIGIN 0.725 2.630 ;
  SIZE 24.550 BY 2.970 ;
  OBS
      LAYER nwell ;
        RECT -0.480 -1.440 23.825 0.180 ;
      LAYER li1 ;
        RECT -0.295 0.130 23.645 0.300 ;
        RECT 0.065 -0.110 0.235 0.130 ;
        RECT 2.265 -0.110 2.435 0.130 ;
        RECT -0.275 -1.155 0.235 -0.110 ;
        RECT -0.725 -1.785 -0.395 -1.455 ;
        RECT 0.515 -1.535 0.685 -0.110 ;
        RECT 1.925 -1.155 2.435 -0.110 ;
        RECT 0.965 -1.535 1.295 -1.455 ;
        RECT 0.515 -1.705 1.295 -1.535 ;
        RECT -0.275 -2.245 0.235 -1.915 ;
        RECT 0.515 -2.245 0.685 -1.705 ;
        RECT 0.965 -1.785 1.295 -1.705 ;
        RECT 1.475 -1.785 1.805 -1.455 ;
        RECT 2.715 -1.845 2.885 -0.110 ;
        RECT 3.525 -1.155 3.695 0.130 ;
        RECT 7.000 -0.110 7.170 0.130 ;
        RECT 8.585 -0.110 8.755 0.130 ;
        RECT 3.075 -1.635 3.405 -1.305 ;
        RECT 3.865 -1.480 4.035 -0.110 ;
        RECT 4.315 -0.985 4.485 -0.110 ;
        RECT 4.315 -1.155 6.460 -0.985 ;
        RECT 6.660 -1.155 7.170 -0.110 ;
        RECT 3.865 -1.650 5.035 -1.480 ;
        RECT 3.865 -1.655 4.235 -1.650 ;
        RECT 3.865 -1.845 4.035 -1.655 ;
        RECT 1.925 -2.245 2.435 -1.915 ;
        RECT 2.715 -2.020 4.035 -1.845 ;
        RECT 2.715 -2.245 2.885 -2.020 ;
        RECT 4.865 -2.245 5.035 -1.650 ;
        RECT 5.315 -2.245 5.485 -1.155 ;
        RECT 5.655 -1.715 5.990 -1.385 ;
        RECT 6.290 -1.455 6.460 -1.155 ;
        RECT 6.210 -1.785 6.540 -1.455 ;
        RECT 7.450 -1.535 7.620 -0.110 ;
        RECT 8.245 -1.155 8.755 -0.110 ;
        RECT 7.795 -1.535 8.125 -1.455 ;
        RECT 7.450 -1.705 8.125 -1.535 ;
        RECT 0.065 -2.420 0.235 -2.245 ;
        RECT 2.265 -2.420 2.435 -2.245 ;
        RECT 5.655 -2.420 5.825 -1.915 ;
        RECT 6.660 -2.245 7.170 -1.915 ;
        RECT 7.450 -2.245 7.620 -1.705 ;
        RECT 7.795 -1.785 8.125 -1.705 ;
        RECT 8.245 -2.245 8.755 -1.915 ;
        RECT 9.035 -1.920 9.205 -0.110 ;
        RECT 9.840 -1.155 10.010 0.130 ;
        RECT 9.390 -1.635 9.720 -1.305 ;
        RECT 10.180 -1.920 10.350 -0.110 ;
        RECT 10.630 -0.985 10.800 -0.110 ;
        RECT 11.555 -0.985 11.885 -0.905 ;
        RECT 10.630 -1.155 11.885 -0.985 ;
        RECT 13.065 -1.155 13.235 0.130 ;
        RECT 16.530 -0.110 16.700 0.130 ;
        RECT 18.110 -0.110 18.280 0.130 ;
        RECT 11.555 -1.235 11.885 -1.155 ;
        RECT 11.180 -1.920 11.350 -1.915 ;
        RECT 9.035 -2.090 11.350 -1.920 ;
        RECT 9.035 -2.245 9.205 -2.090 ;
        RECT 11.180 -2.245 11.350 -2.090 ;
        RECT 11.630 -2.245 11.800 -1.235 ;
        RECT 12.070 -1.660 12.405 -1.330 ;
        RECT 12.615 -1.635 12.945 -1.305 ;
        RECT 13.405 -1.480 13.575 -0.110 ;
        RECT 13.855 -0.985 14.025 -0.110 ;
        RECT 13.855 -1.155 15.990 -0.985 ;
        RECT 16.190 -1.155 16.700 -0.110 ;
        RECT 13.405 -1.650 14.575 -1.480 ;
        RECT 13.405 -1.850 13.575 -1.650 ;
        RECT 7.000 -2.420 7.170 -2.245 ;
        RECT 8.585 -2.420 8.755 -2.245 ;
        RECT 11.990 -2.420 12.160 -1.915 ;
        RECT 13.325 -2.180 13.655 -1.850 ;
        RECT 14.405 -2.245 14.575 -1.650 ;
        RECT 14.855 -2.245 15.025 -1.155 ;
        RECT 15.195 -1.715 15.530 -1.385 ;
        RECT 15.820 -1.455 15.990 -1.155 ;
        RECT 15.740 -1.785 16.070 -1.455 ;
        RECT 16.980 -1.535 17.150 -0.110 ;
        RECT 17.770 -1.155 18.280 -0.110 ;
        RECT 17.320 -1.535 17.650 -1.455 ;
        RECT 16.980 -1.705 17.650 -1.535 ;
        RECT 15.195 -2.420 15.365 -1.915 ;
        RECT 16.190 -2.245 16.700 -1.915 ;
        RECT 16.980 -2.245 17.150 -1.705 ;
        RECT 17.320 -1.785 17.650 -1.705 ;
        RECT 17.770 -2.245 18.280 -1.915 ;
        RECT 18.560 -1.920 18.730 -0.110 ;
        RECT 19.375 -1.155 19.545 0.130 ;
        RECT 22.960 -0.110 23.130 0.130 ;
        RECT 18.925 -1.635 19.255 -1.305 ;
        RECT 19.715 -1.920 19.885 -0.110 ;
        RECT 20.165 -0.985 20.335 -0.110 ;
        RECT 21.090 -0.985 21.420 -0.905 ;
        RECT 20.165 -1.155 21.420 -0.985 ;
        RECT 22.620 -1.155 23.130 -0.110 ;
        RECT 21.090 -1.235 21.420 -1.155 ;
        RECT 20.715 -1.920 20.885 -1.915 ;
        RECT 18.560 -2.090 20.885 -1.920 ;
        RECT 18.560 -2.245 18.730 -2.090 ;
        RECT 20.715 -2.245 20.885 -2.090 ;
        RECT 21.165 -2.245 21.335 -1.235 ;
        RECT 21.605 -1.660 21.935 -1.330 ;
        RECT 22.170 -1.785 22.500 -1.455 ;
        RECT 16.530 -2.420 16.700 -2.245 ;
        RECT 18.110 -2.420 18.280 -2.245 ;
        RECT 21.525 -2.420 21.695 -1.915 ;
        RECT 22.620 -2.245 23.130 -1.915 ;
        RECT 23.410 -2.245 23.580 -0.110 ;
        RECT 22.960 -2.420 23.130 -2.245 ;
        RECT -0.300 -2.590 23.640 -2.420 ;
      LAYER met1 ;
        RECT -0.295 0.095 23.645 0.340 ;
        RECT 11.555 -0.985 11.885 -0.905 ;
        RECT 21.090 -0.985 21.420 -0.905 ;
        RECT 6.290 -1.155 11.885 -0.985 ;
        RECT -0.725 -1.785 -0.395 -1.455 ;
        RECT 0.965 -1.785 1.295 -1.455 ;
        RECT 3.075 -1.635 3.405 -1.305 ;
        RECT 5.655 -1.715 5.990 -1.385 ;
        RECT 6.290 -1.455 6.460 -1.155 ;
        RECT 11.555 -1.235 11.885 -1.155 ;
        RECT 15.820 -1.155 21.420 -0.985 ;
        RECT 6.210 -1.785 6.540 -1.455 ;
        RECT 7.795 -1.785 8.125 -1.455 ;
        RECT 9.390 -1.635 9.720 -1.305 ;
        RECT 12.070 -1.660 12.405 -1.330 ;
        RECT 12.615 -1.635 12.945 -1.305 ;
        RECT 15.195 -1.715 15.530 -1.385 ;
        RECT 15.820 -1.455 15.990 -1.155 ;
        RECT 21.090 -1.235 21.420 -1.155 ;
        RECT 15.740 -1.785 16.070 -1.455 ;
        RECT 17.320 -1.785 17.650 -1.455 ;
        RECT 18.925 -1.635 19.255 -1.305 ;
        RECT 21.605 -1.660 21.935 -1.330 ;
        RECT 22.170 -1.785 22.500 -1.455 ;
        RECT 7.875 -1.925 8.045 -1.785 ;
        RECT 13.325 -1.925 13.655 -1.850 ;
        RECT 7.875 -2.095 13.655 -1.925 ;
        RECT 13.325 -2.180 13.655 -2.095 ;
        RECT 17.400 -1.935 17.570 -1.785 ;
        RECT 22.250 -1.935 22.420 -1.785 ;
        RECT 17.400 -2.105 22.420 -1.935 ;
        RECT -0.340 -2.630 23.640 -2.385 ;
      LAYER met2 ;
        RECT 1.050 -1.165 21.860 -0.995 ;
        RECT 1.050 -1.455 1.220 -1.165 ;
        RECT -0.725 -1.785 -0.395 -1.455 ;
        RECT 0.965 -1.785 1.295 -1.455 ;
        RECT 3.075 -1.635 3.405 -1.305 ;
        RECT 5.740 -1.385 5.910 -1.165 ;
        RECT 9.470 -1.305 9.640 -1.165 ;
        RECT 12.695 -1.305 12.865 -1.165 ;
        RECT -0.645 -2.030 -0.475 -1.785 ;
        RECT 3.155 -2.030 3.325 -1.635 ;
        RECT 5.655 -1.715 5.990 -1.385 ;
        RECT 9.390 -1.635 9.720 -1.305 ;
        RECT 12.070 -1.665 12.405 -1.330 ;
        RECT 12.615 -1.635 12.945 -1.305 ;
        RECT 12.155 -2.030 12.325 -1.665 ;
        RECT 15.195 -1.715 15.530 -1.385 ;
        RECT 18.925 -1.635 19.255 -1.305 ;
        RECT 21.690 -1.330 21.860 -1.165 ;
        RECT 15.280 -2.030 15.450 -1.715 ;
        RECT 19.005 -2.030 19.175 -1.635 ;
        RECT 21.605 -1.660 21.935 -1.330 ;
        RECT -0.645 -2.200 19.175 -2.030 ;
  END
END d_ff
END LIBRARY

